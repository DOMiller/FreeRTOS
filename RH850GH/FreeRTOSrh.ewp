# IAR project FreeRTOSrh.ewp, settings and files
configuration Debug (RH850, debug)
  General.GDeviceSelect: R7F701422 RH850 - R7F701422
  General.GHeapSize: 4096
  ICCRH850.IccLang: 0
  ICCRH850.CCOptLevel: 0
  ICCRH850.CCOptStrategy: 0
  ICCRH850.CCDefines: __ICCRH850__
  ICCRH850.CCDiagSuppress: Pa082
  ICCRH850.CCIncludePath2: ..\..\Source\include; ..\Common\include; LEDtoggle; IntV850ES; $PROJ_DIR$; D:\users\f23427c\Source\FreeRTOSV\FreeRTOS\Source\portable\IAR\V850ES
  IASMRH850.AsmIncludePath: $PROJ_DIR$; ..\..\Source\portable\IAR\V850ES
  OBJCOPY.OOCOutputFile: FreeRTOSrh.srec
  ILINK.IlinkOutputFile: FreeRTOSrh.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start1
configuration Release (RH850)
  as the first configuration, except:
  ICCRH850.CCOptLevel: 3
  ICCRH850.CCDefines: NDEBUG
  group demo source
    ./: main.c RegTest.asm
    serial/: serial.c serialISR.asm
  group demo source/LEDs
    ParTest/: ParTest_Fx3_App_Board.c ParTest_Generic_Target_Board.c
  group demo source/Low Level Init
    LowLevelInit/: LowLevelInit.c LowLevelInit_Fx3.c LowLevelInit_Hx2.c
  group demo source/Standard Demo Tasks
    ../Common/Minimal/: BlockQ.c comtest.c death.c flash.c GenQTest.c PollQ.c QPeek.c recmutex.c semtest.c
  group kernel source
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/: list.c queue.c tasks.c
    ../../Source/portable/IAR/V850ES/: port.c
  group kernel source/device specific
    ../../Source/portable/IAR/V850ES/: portasm.asm portasm_Fx3.asm portasm_Hx2.asm
